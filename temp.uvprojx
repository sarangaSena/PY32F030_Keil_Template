# Keil uVision project temp.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: temp
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: .\Drivers\PY32F0xx_HAL_Driver\Inc;.\Drivers\BSP\PY32F030xx_Start_Kit;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\PY32F0xx\Include;.\Core\Inc;.\Peripherals\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./Startup/: system_py32f0xx.c startup_py32f030xx.s
  group Core
    ./Core/Src/: py32f0xx_hal_msp.c py32f0xx_it.c main.c
  group Drivers/PY32F0xx_HAL_Driver
    ./Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group BSP/py32f030xx_Start_Kit
    ./Drivers/BSP/PY32F030xx_Start_Kit/: py32f030xx_Start_Kit.c
software components: CMSIS:CORE 6.0.0
